# Keil uVision project DcServoDriver.uvprojx, settings and files
target STM32F103xB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VenderSpecificUsb +hex
  c flags: Optim=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_USB_FS,STM32F103xB,USE_USB
  c include: ..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Lib\STM32_USB_Device_Library\Class\VendorSpecific\Inc;..\Lib\STM32_USB_Device_Library\Core\Inc;..\User\Header;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Lib\STM32_USB_Device_Library\Class\CDC_Interface\header;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/Source/: board.c CloseLoopControl.c command.c crc.c delay.c EncoderIncremental.c error.c ExternalCounter.c main.c rs485.c status.c stm32f1xx_it.c string_user.c transfer.c
  group Driver/Periperal
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Driver/Cmx
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../User/: startup_stm32f103xb.s
  group Lib/Usb/Core
    ../Lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c usbd_conf.c
  group Lib/Usb/Class/VenderSpencific
    ../Lib/STM32_USB_Device_Library/Class/VendorSpecific/Src/: usbd_specific.c usbd_spencific_desc.c
  group Document
    ./: sensorCaculater.txt
  group Lib/Usb/Class/CdcClass
    ../Lib/STM32_USB_Device_Library/Class/CDC_Interface/source/: usbd_cdc.c usbd_cdc_desc.c usbd_cdc_interface.c
software components: CMSIS:CORE 5.0.1
